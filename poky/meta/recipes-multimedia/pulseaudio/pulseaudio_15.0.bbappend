FILES:${PN}-misc:append = " ${bindir}/pactl ${bindir}/pacmd"
