FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://v4l2.cfg \
    file://mirroring.cfg \
    file://xen.cfg \
"
