FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://xen.cfg \
"

